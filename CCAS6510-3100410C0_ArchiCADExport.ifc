Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-09-21T07:30:51
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20210416_1515(x64) - Exporter 19.2.30.41 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: CCAS6510-3100410C0, AmericanStandard_Urinal_Flexbrook_(CCAS6510-3100410C0):CCAS6510-3100410C0:3406
In: Level 1
Classification: C1030200 (Uniformat); Material: Porcelain - White
Pset_ManufacturerTypeInformation - ModelReference: CCAS6510-3100410C0; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: CCAS6510-3100410C0
Constraints - Elevation: 0 mm
Dimensions - Area: 0.420758 m2; Volume: 0.0511479 m3
Identity Data - Mark: 1
Other - AssetIdentifier: Please record on commissioning; BarCode: Please record on commissioning; Category: Plumbing Fixtures; Family: AmericanStandard_Urinal_Flexbrook_(CCAS6510-3100410C0): CCAS6510-3100410C0; Family and Type: AmericanStandard_Urinal_Flexbrook_(CCAS6510-3100410C0): CCAS6510-3100410C0; InstallationDate: Please record on commissioning; SerialNumber: Please record on commissioning; Type: AmericanStandard_Urinal_Flexbrook_(CCAS6510-3100410C0): CCAS6510-3100410C0; Type Id: AmericanStandard_Urinal_Flexbrook_(CCAS6510-3100410C0): CCAS6510-3100410C0; WarrantyStartDate: Please record on commissioning
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 610 mm
Identity Data(Type) - Assembly Code: C1030200; Description: Flexbrook urinal (back-inlet) 0.5L, HEAI; Keynote: N13; Manufacturer: American Standard; Model: CCAS6510-3100410C0; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Comments: Flexbrook urinal (back-inlet) 0.5L, HEAI; Type Name: CCAS6510-3100410C0; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/flexbrook-0-5l-urinal-ccas6510-3100410c0/document/object-user-guide; BIMObjectName: AmericanStandard_Urinal_Flexbrook_(CCAS6510-3100410C0); NBSDescription: Wall-hung urinals; NBSNote: n/a; NBSObjectName: American Standard - Wall-hung urinals; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/350
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_93_82; CodePerformance: n/a; Color: White; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-08-24 T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/flexbrook-0-5l-urinal-ccas6510-3100410c0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/flexbrook-0-5l-urinal-ccas6510-3100410c0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/flexbrook-0-5l-urinal-ccas6510-3100410c0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/flexbrook-0-5l-urinal-ccas6510-3100410c0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/flexbrook-0-5l-urinal-ccas6510-3100410c0/document/technical-data-sheet; DurationUnit: Year; ExpectedLife: 0; Family Name: AmericanStandard_Urinal_Flexbrook_(CCAS6510-3100410C0); Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: Flexbrook urinal (back-inlet) 0.5L, HEAI; ModelReference: CCAS6510-3100410C0; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: CCAS6510-3100410C0; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
